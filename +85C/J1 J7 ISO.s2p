!Agilent Technologies,N5230A,MY45001360,A.07.50.67
!Agilent N5230A: A.07.50.67
!Date: Tuesday, April 16, 2024 17:48:31
!Correction: S11(Full 2 Port(1,2))
!S21(Full 2 Port(1,2))
!S12(Full 2 Port(1,2))
!S22(Full 2 Port(1,2))
!S2P File: Measurements: S11, S21, S12, S22:
# Hz S  dB  R 50
! Worked out from all points (one-way two-port):
!   201 points, 500 MHz to 18 GHz, reference 50 ohm
!   highest |S21| = -79.18 dB at 16.07 GHz (marker M1); lowest = -122.1 dB at 13.36 GHz (marker M2)
!   lowest |S11| = -22.6 dB at 16.86 GHz (marker M3), VSWR 1.16, Z = 52.3 + j7.21 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
!   |S22| runs from -56.0 to -9.4 dB; largest |S21 - S12| = 0.00011
!   S11 on the Smith chart (normalised r, x): 500 MHz: 1.18, -0.18; 4.963 GHz: 0.93, -0.28; 7.938 GHz: 1.61, -0.04; 10.74 GHz: 0.81, +0.26; 18 GHz: 1.14, +0.40
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 500 MHz  -18.7  -92.7  -112.4  -27.1
! 1.9 GHz  -21.0  -103.1  -114.6  -33.4
! 2.163 GHz  -19.4  -96.3  -110.1  -42.4
! 2.25 GHz  -18.7  -105.6  -115.4  -56.0
! 2.425 GHz  -17.5  -102.6  -116.2  -38.7
! 2.6 GHz  -16.3  -109.2  -111.8  -30.4
! 3.475 GHz  -16.1  -101.0  -109.6  -23.7
! 4.175 GHz  -21.4  -94.9  -109.2  -22.4
! 4.963 GHz  -16.5  -102.3  -106.1  -25.2
! 5.662 GHz  -20.2  -97.3  -108.7  -40.6
! 6.362 GHz  -16.0  -97.5  -109.0  -25.6
! 7.938 GHz  -12.6  -102.5  -105.9  -24.4
! 9.25 GHz  -12.7  -98.0  -102.9  -16.0
! 10.74 GHz  -15.2  -94.1  -92.3  -17.8
! 11.35 GHz  -14.1  -105.9  -114.1  -20.7
! 12.22 GHz  -11.4  -107.1  -99.9  -15.8
! 13.36 GHz  -12.6  -122.1  -112.2  -16.5
! 14.06 GHz  -13.0  -92.5  -105.2  -20.0
! 15.11 GHz  -11.7  -96.3  -98.3  -12.5
! 16.07 GHz  -18.3  -79.2  -86.3  -12.5
! 16.86 GHz  -22.6  -85.4  -94.3  -16.8
! 18 GHz  -14.2  -94.4  -91.9  -9.4
